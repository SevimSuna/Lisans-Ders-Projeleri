ORG 0H
SJMP BASLA
ORG 30H
	
BASLA:	MOV P1, #0FFH
		MOV P2, #0
		CLR A
		MOV	DPTR, #005FH
BAS:	JB P1.0, BAS
CALIS:	CALL SAY
		MOV P2,A
		MOV A, R2
		CALL GECIKME
		CJNE A, #16, CALIS
		SJMP BASLA
GECIKME:	MOV R0, #255
		MOV R1, #255
BEKLE:	DJNZ R0, BEKLE
		MOV R0, #255
		DJNZ R1, BEKLE
		RET
SAY:	INC A
		MOV R2,A
		MOVC A, @A+DPTR
		RET
		ORG 60H
TABLO:	DB	2DH, 2DH, 2DH, 2DH
		DB	2DH, 2DH, 2DH, 2DH
		//DB	7FH, 6FH, 77H, 7CH
		//DB	39H, 5EH, 79H, 71H
		END